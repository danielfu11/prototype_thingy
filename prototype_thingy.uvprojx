# Keil uVision project prototype_thingy.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.2
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: prototype_thingy
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF_LOG_ENABLED=1, NRF_LOG_USES_RTT=1
  c include: ..\nRF5_SDK_12.3.0_d7731ad\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\pdm;..\Nordic-Thingy52-FW\external\sdk13\components\libraries\util;..\Nordic-Thingy52-FW\external\sdk13\components\softdevice\s140\headers;..\Nordic-Thingy52-FW\project\pca20020_s132\config;..\Nordic-Thingy52-FW\external\sdk13\components\drivers_nrf\common;..\Nordic-Thingy52-FW\external\sdk13\components\drivers_nrf\hal;..\Nordic-Thingy52-FW\external\sdk13\components\libraries\log;..\Nordic-Thingy52-FW\external\sdk13\components\libraries\log\src;.\RTE\nRF_Libraries\nRF52832_xxAA;..\Nordic-Thingy52-FW\external\sdk13\components\libraries\strerror;..\Nordic-Thingy52-FW\external\sdk13\components\drivers_nrf\hal
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20002000 size 0xe000
  group Main
    ./: main.c configuration.c configuration.h interrupts.c interrupts.h
    ../nRF5_SDK_12.3.0_d7731ad/nRF5_SDK_12.3.0_d7731ad/components/drivers_nrf/pdm/: nrf_drv_pdm.c
    ../Nordic-Thingy52-FW/external/sdk13/components/libraries/util/: sdk_common.h sdk_errors.h
    ../Nordic-Thingy52-FW/external/sdk13/components/softdevice/s140/headers/: nrf_error.h
    ../Nordic-Thingy52-FW/project/pca20020_s132/config/: sdk_config.h
    ../Nordic-Thingy52-FW/external/sdk13/components/drivers_nrf/common/: nrf_drv_common.h nrf_drv_common.c
    ../Nordic-Thingy52-FW/external/sdk13/components/drivers_nrf/hal/: nrf_peripherals.h nrf_uart.h
    ../Nordic-Thingy52-FW/external/sdk13/components/libraries/log/: nrf_log.h nrf_log_backend.h nrf_log_ctrl.h
    ../Nordic-Thingy52-FW/external/sdk13/components/libraries/log/src/: nrf_log_internal.h nrf_log_ctrl_internal.h nrf_log_backend_serial.c nrf_log_frontend.c
    ../Nordic-Thingy52-FW/external/sdk13/components/libraries/strerror/: nrf_strerror.c nrf_strerror.h
software components: CMSIS:CORE 5.0.2, Device:Startup 8.15.2, Device:StartupConfig 8.15.2, nRF_Drivers:nrf_clock 4.0.0-2.alpha, nRF_Drivers:nrf_gpio 4.0.0-2.alpha, nRF_Drivers:nrf_gpiote 4.0.0-2.alpha, nRF_Drivers:nrf_i2s 4.0.0-2.alpha, nRF_Drivers:nrf_nvmc 4.0.0-2.alpha, nRF_Drivers:nrf_pdm 4.0.0-2.alpha, nRF_Drivers:nrf_ppi 4.0.0-2.alpha, nRF_Drivers:nrf_pwm 4.0.0-2.alpha, nRF_Drivers:nrf_spi 4.0.0-2.alpha, nRF_Drivers:nrf_spim 4.0.0-2.alpha, nRF_Libraries:segger_rtt 1.2.1-2.alpha
